FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://defconfig"
COMPATIBLE_MACHINE_am57xx-hs-evm = "am57xx-hs-evm"
COMPATIBLE_MACHINE_am57xx-evm = "am57xx-evm"
