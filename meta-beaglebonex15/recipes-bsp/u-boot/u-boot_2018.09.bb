UBOOT_SUFFIX="img"
SPL_BINARY="MLO"

require u-boot-common_${PV}.inc
require u-boot.inc
