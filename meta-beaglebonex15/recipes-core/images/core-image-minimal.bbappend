IMAGE_INSTALL_append = "xenomai"
